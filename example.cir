V1 1 0 30
R1 1 0 5k

.OP V1
.END